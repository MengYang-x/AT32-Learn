# Keil uVision project ST7735.uvprojx, settings and files
target ST7735 (6160000::V6.16::ARMCLANG)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.8
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: ST7735 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\st7735s;..\..\user_config;..\..\st7735s\fonts
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32f421_int.c at32f421_wk_config.c main.c wk_system.c wk_usart.c wk_gpio.c
  group firmware
    ../../libraries/drivers/src/: at32f421_crm.c at32f421_gpio.c at32f421_usart.c at32f421_pwc.c at32f421_debug.c at32f421_flash.c at32f421_misc.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ./: startup_at32f421.s
  group st7735s
    ../../st7735s/: st7735s.c
  group user_config
    ../../user_config/: user_config.h
